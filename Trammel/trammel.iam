# Autodesk Inventor assembly: trammel
## iProperties
Created: 2008-12
Part Number: trammel
Document SubType Name: Assembly
Designer: Lochan
Author: Lochan
